# Keil uVision project demo.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: keyLED +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\USERS\HardWare;.\USERS
  asm include: .\USERS;.\USERS\HardWare
  group Source Group 1
    ./: STARTUP.A51
  group HardWare
    ./USERS/HardWare/: gpio.c timer.c motor.c delay.c
  group Users
    ./USERS/: main.c
